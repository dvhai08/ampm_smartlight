# Keil uVision project VT_SMARTLIGHT_STM32F4.uvprojx, settings and files
target VT_SMARTLIGHT_STM32F4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: VT_SMARTLIGHT_STM32F4
  AfterMake: fromelf --bin --output .\output\VT_SML_HCM_V1.bin .\VT_SMARTLIGHT_STM32F4\VT_SMARTLIGHT_STM32F4.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,CMSIS_OS_RTX,ENABLE_IOT_DEBUG,__STDC_FORMAT_MACROS
  c misc: --C99 --gnu
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;    ../Middlewares/Third_Party/FreeRTOS/Source/include;    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;    ../Drivers/CMSIS/Include;    ..\ampm_lib;    ..\ampm_lib\common;    ..\ampm_lib\ampm_gsm;    ..\EthernetInterface;    ..\EthernetInterface/Socket;    ..\EthernetInterface/lwip-eth;    ..\EthernetInterface/lwip-eth/arch;    ..\EthernetInterface/lwip-sys;    ..\EthernetInterface/lwip-sys/arch;    ..\EthernetInterface/lwip;    ..\EthernetInterface/lwip/api;    ..\EthernetInterface/lwip/core;    ..\EthernetInterface/lwip/core/ipv4;    ..\EthernetInterface/lwip/core/snmp;    ..\EthernetInterface/lwip/include;    ..\EthernetInterface/lwip/include/ipv4;    ..\EthernetInterface/lwip/include/ipv4/lwip;    ..\EthernetInterface/lwip/include/lwip;    ..\EthernetInterface/lwip/include/netif;    ..\EthernetInterface/lwip/netif;    ..\EthernetInterface/lwip/netif/ppp;    ..\aws_iot;    ..\aws_iot\certs;    ..\aws_iot\external_libs;    ..\aws_iot\external_libs\CppUTest;    ..\aws_iot\external_libs\jsmn;    ..\aws_iot\include;    ..\aws_iot\platform\mbed_os\mbedtls;    ..\aws_iot\platform;    ..\aws_iot\platform\lwip\mbedtls;    ..\aws_iot\platform\lwip\common;    ..\aws_iot\src;    ..\Middlewares\Third_Party\mbedtls\inc;    ..\Middlewares\Third_Party\mbedtls\inc\mbedtls;    ..\aws_iot\platform\lwip\pthread;    ..\Src\FreeRTOS_CLI;    ..\Middlewares\Third_Party\FreeRTOS-Plus-CLI;    ..\Middlewares\Third_Party\FreeRTOS-Plus-Trace\Include;    ..\Src\alarm;    ..\Src\device_admin;    ..\Src\relay;    ..\ampm_lib\flash_mem;    ..\Middlewares\Third_Party\spiffs\src;    ..\Middlewares\Third_Party\spiffs\src\test
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\VT_SMARTLIGHT_STM32F4.sct
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c queue.c tasks.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group FreeRTOS_CLI
    ../Middlewares/Third_Party/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group FreeRTOS_Trace
    ../Middlewares/Third_Party/FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
  group AmpmLib
    ../ampm_lib/lib/: ampm_list.c ampm_sprintf.c crc16.c data_cmp.c DTMF.c encoding.c fcs.c m_time.c packet_queue.c ringbuf.c sparser.c sys_tick.c sys_time.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_hal_timebase_TIM.c freertos.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c uart1.c uart5.c system_config.c shadow_thing.c ntp_server.c smartlight.c ota_server.c watchdog.c sms_task.c spi1.c io_control.c led.c uart4.c ota_backup_server.c uart6.c power_sensor.c
    ../Middlewares/Third_Party/mbedtls/platform/src/: hardware_rng.c
    ../Src/FreeRTOS_CLI/: CLI-commands.c Run-time-stats-utils.c UARTCommandConsole.c
    ../ampm_lib/flash_mem/: sst25.c
  group pc_config
    ../Src/: app_config_task.c uart_config_task.c
  group alarm
    ../Src/alarm/: alarm.c ac_line_out_alert.c
  group auth
    ../Src/device_admin/: auth.c device_info.c
  group relay
    ../Src/relay/: relay.c
  group AMPM_GSM
    ../ampm_lib/ampm_gsm/: ampm_gsm_call.c ampm_gsm_common.c ampm_gsm_dial_up.c ampm_gsm_io.c ampm_gsm_main_task.c ampm_gsm_ring.c ampm_gsm_sms.c ampm_gsm_startup.c at_command_parser.c ampm_gsm_sms_api.c
    ../ampm_lib/common/: comm.c
    ../ampm_lib/ampm_gsm/sms/: pdu.c
  group lwip_api
    ../EthernetInterface/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c lwip_net_socket.c
    ../Src/: lwip_stack.c
  group lwip_arch
    ../EthernetInterface/lwip-sys/arch/: checksum.c memcpy.c sys_arch.c
  group lwip_core
    ../EthernetInterface/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group lwip_ipv4
    ../EthernetInterface/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../EthernetInterface/lwip/netif/: etharp.c ethernetif.c sio.c slipif.c
  group lwip_ppp
    ../EthernetInterface/lwip/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group lwip_snmp
    ../EthernetInterface/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group aws_iot
    ../aws_iot/src/: aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c
    ../aws_iot/platform/lwip/common/: aws_timer.c
    ../aws_iot/platform/lwip/mbedtls/: net_socket.c network_notls_wrapper.c network_mbedtls_wrapper.c
    ../aws_iot/external_libs/jsmn/: jsmn.c
    ../Middlewares/Third_Party/mbedtls/src/: net_sockets.c
  group mbedtls
    ../Middlewares/Third_Party/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group spiffs
    ../Middlewares/Third_Party/spiffs/src/: spiffs_cache.c spiffs_nucleus.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c
    ../Middlewares/Third_Party/spiffs/src/test/: test_spiffs.c
software components: CMSIS:CORE 4.1.0
