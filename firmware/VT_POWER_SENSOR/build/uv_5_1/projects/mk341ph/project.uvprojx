# Keil uVision project project.uvprojx, settings and files
target release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKM33Z128xxx5 NXP
  pack: Keil.Kinetis_KMxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG,MESH_NET_SUPPORT,HAS_HOST_UART,GSM_SUPPORT
  c misc: --diag_suppress=1,951 --c99 --bss_threshold=0
  c include: ..\..\..\..\src\common;..\..\..\..\src\common\headers;..\..\..\..\src\drivers;..\..\..\..\src\freemaster;..\..\..\..\src\toolchain\uv;..\..\..\..\src\meterlib;..\..\..\..\src\fraclib;..\..\..\..\src\projects\mk341ph;..\..\..\..\src\projects\mk341ph;..\..\..\..\src\ampm_lib;..\..\..\..\src\ampm_lib\uip;..\..\..\..\src\ampm_lib\ampm_gsm;..\..\..\..\src\ampm_lib\common;..\..\..\..\src\ampm_lib\PPP;..\..\..\..\src\ampm_lib\uip-ppp-lib;..\..\..\..\src\ampm_lib\flash_mem;..\..\..\..\src\polarssl-1.3.8\include;..\..\..\..\src\polarssl-1.3.8;..\..\..\..\src\dlt645
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\MKMxxZ128_flash_NVM.scf
  link misc: --entry=__uv_program_start --diag_suppress=6312 --diag_suppress=6314 --diag_suppress=6329 --startup=__uv_program_start
  group system_config
    ../../../../src/projects/mk341ph/: system_config.c
  group project
    ../../../../src/projects/mk341ph/: main.c smarthome_meter.c app_rtc.c auto_calib.c
  group common
    ./: MKMxxZ128_flash_NVM.scf
    ../../../../src/common/: arm_cm0.c start.c system.c delay.c
  group toolchain
    ../../../../src/toolchain/uv/: arch_delay.s crt0.s startup.c
  group drivers
    ../../../../src/drivers/adc/: adc.c adc.h
    ../../../../src/drivers/afe/: afe.c afe.h
    ../../../../src/drivers/fll/: fll.c fll.h
    ../../../../src/drivers/ftfa/: ftfa.c ftfa.h
    ../../../../src/drivers/gpio/: gpio.c gpio.h
    ../../../../src/drivers/i2c/: i2c.c i2c.h
    ../../../../src/drivers/irtc/: irtc.c irtc.h
    ../../../../src/drivers/llwu/: llwu.c llwu.h
    ../../../../src/drivers/lptmr/: lptmr.c lptmr.h
    ../../../../src/drivers/mcm/: mcm.c mcm.h
    ../../../../src/drivers/mpu/: mpu.c mpu.h
    ../../../../src/drivers/osc/: osc.c osc.h
    ../../../../src/drivers/osc32k/: osc32k.c osc32k.h
    ../../../../src/drivers/pit/: pit.c pit.h
    ../../../../src/drivers/pll/: pll.c pll.h
    ../../../../src/drivers/pmc/: pmc.c pmc.h
    ../../../../src/drivers/rcm/: rcm.c rcm.h
    ../../../../src/drivers/rnga/: rnga.c rnga.h
    ../../../../src/drivers/sim/: sim.c sim.h
    ../../../../src/drivers/smc/: smc.c smc.h
    ../../../../src/drivers/spi/: spi.c spi.h
    ../../../../src/drivers/swisr/: swisr.c swisr.h
    ../../../../src/drivers/syst/: syst.c syst.h
    ../../../../src/drivers/tmr/: tmr.c tmr.h
    ../../../../src/drivers/uart/: uart.c uart.h
    ../../../../src/drivers/wdog/: wdog.c wdog.h
    ../../../../src/drivers/vref/: vref.c vref.h
    ../../../../src/drivers/: drivers.h
    ../../../../src/drivers/xbar/: xbar.c xbar.h
    ../../../../src/drivers/cmp/: cmp.c
  group meterlib
    ../../../../src/meterlib/: meterlib1ph.c
  group fraclib
    ../../../../src/fraclib/: fraclib.c fraclib.h FRACLIB_Inlines.h FRACLIB_Mul32.h FRACLIB_Mul32.s FRACLIB_Types.h
  group ampm_lib
    ../../../../src/ampm_lib/common/: comm.c
    ../../../../src/ampm_lib/lib/: ampm_sprintf.c data_cmp.c encoding.c fcs.c list.c m_time.c packet_queue.c protocol.c ringbuf.c sparser.c sys_tick.c sys_time.c tick.c
  group eeprom
    ../../../../src/projects/mk341ph/: i2ceeprom.c
target debug (ARM-ADS)
  device: MKM14Z128xxx5 NXP
  pack: Keil.Kinetis_KMxx_DFP.1.3.0
  cpu: as above
  output: project +hex
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG AMPM_SMARTPLUG_V5
  c misc: --diag_suppress=1,951 --c99 --bss_threshold=0
  c include: ..\..\..\..\src\common;..\..\..\..\src\common\headers;..\..\..\..\src\drivers;..\..\..\..\src\freemaster;..\..\..\..\src\toolchain\uv;..\..\..\..\src\meterlib;..\..\..\..\src\fraclib;..\..\..\..\src\projects\mk341ph;..\..\..\..\src\projects\mk341ph;..\..\..\..\src\ampm_lib;..\..\..\..\src\ampm_lib\common;..\..\..\..\src\soft_spi
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\MKMxxZ128_flash_NVM.scf
  link misc: as above
software components: CMSIS:CORE 5.0.1
